<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lowres_converter</value></param>
<param><key>author</key><value>Eder Oliveira de Souza</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Low Resolution Converter</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>blocks_complex_to_imag</key>
<param><key>id</key><value>blocks_complex_to_imag_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vect_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vect_len</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vect_len</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vect_len</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, vector_size=24, num_bits=3):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.vector_size = vector_size
        self.num_bits = num_bits
        gr.sync_block.__init__(
            self,
            name='quant_uniform',   # will show up in GRC
            in_sig=[(np.float32, vector_size)],
            out_sig=[(np.float32,vector_size)]
        )

    def work(self, input_items, output_items):
        x = input_items[0][:]
        x_min = np.min(x)
        x_max = np.max(x)
        N = 2 ** self.num_bits
        delta = (x_max - x_min) / N
        y = np.arange(x_min + delta / 2, x_max, delta)
        t = np.array([(y[0:N - 1] + y[1:N]) / 2])
        t = np.insert(t, 0, x_min - 1)
        t = np.insert(t, np.size(t), x_max + 1)
        xq = np.zeros_like(x)
        for i in range(N):
            xq = xq + ((t[i] &lt;= x) &amp; (x &lt; t[i + 1])) * y[i]
        output_items[0][:] = xq
        return len(output_items[0])
</value></param>
<param><key>num_bits</key><value>nbits</value></param>
<param><key>vector_size</key><value>vect_len</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, vector_size=24, num_bits=3):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.vector_size = vector_size
        self.num_bits = num_bits
        gr.sync_block.__init__(
            self,
            name='quant_uniform',   # will show up in GRC
            in_sig=[(np.float32, vector_size)],
            out_sig=[(np.float32, vector_size)]
        )

    def work(self, input_items, output_items):
        x = input_items[0][:]
        x_min = np.min(x)
        x_max = np.max(x)
        N = 2 ** self.num_bits
        delta = (x_max - x_min) / N
        y = np.arange(x_min + delta / 2, x_max, delta)
        t = np.array([(y[0:N - 1] + y[1:N]) / 2])
        t = np.insert(t, 0, x_min - 1)
        t = np.insert(t, np.size(t), x_max + 1)
        xq = np.zeros_like(x)
        for i in range(N):
            xq = xq + ((t[i] &lt;= x) &amp; (x &lt; t[i + 1])) * y[i]
        output_items[0][:] = xq
        return len(output_items[0])


</value></param>
<param><key>num_bits</key><value>nbits</value></param>
<param><key>vector_size</key><value>vect_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interp</value></param>
<param><key>label</key><value>Interpolation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nbits</value></param>
<param><key>label</key><value>Num bits</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>label</key><value>Num taps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>352000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>label</key><value>Symbol Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vect_len</value></param>
<param><key>label</key><value>Vector length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>24</value></param>
</block>
<connection><source_block_id>blocks_complex_to_imag_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>epy_block_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_imag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
